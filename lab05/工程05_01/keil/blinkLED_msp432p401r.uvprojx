# Keil uVision project blinkLED_msp432p401r.uvprojx, settings and files
target blinkLED_msp432p401r (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinkLED_msp432p401r
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: ..\source;..\source\third_party\CMSIS\Include;..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group user
    ../: main.c
  group startup
    ../source/ti/devices/msp432p4xx/startup_system_files/keil/: startup_msp432p401r_uvision.s
    ../source/ti/devices/msp432p4xx/startup_system_files/: system_msp432p401r.c
  group lib
    ../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
